require k3s-bin-arch.inc

K3S_VERSION="1.17.2+k3s1"
PR = "${INC_PR}.0"
PV = "${K3S_VERSION}-${PR}"
